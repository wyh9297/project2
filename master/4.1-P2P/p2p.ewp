# IAR project p2p.ewp, settings and files
configuration Release (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
  group (top)
    ./: basic_rf.c bmp280.c bmp280.h clock.c dht11.c dht11.h hal_assert.c hal_board.c hal_int.c hal_mcu.c hal_rf.c main.c readme.txt
